USER = "kristijonaslucenko"
REPO = "ccu-bootloader"

# "barebox_modded" 

# "ccu-bootloader"
SRCREVP = "0f034be57e539212af84dfd53e70faadac40e6f3"


# "a18c9e3b072c336ea89db4540bac84c74ade4708"

# "0f034be57e539212af84dfd53e70faadac40e6f3"
